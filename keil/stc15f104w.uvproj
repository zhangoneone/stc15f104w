# Keil uVision project stc15f104w.uvproj, settings and files
target main (MCS-51)
  device: STC15F104W Series STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: stc15f104w +hex
  c flags: Optimize=9
  group src
    ../src/: STARTUP.A51 main.c
  group inc
    ../inc/: STC15.H
